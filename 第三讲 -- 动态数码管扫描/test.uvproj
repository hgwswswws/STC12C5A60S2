# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\APP;.\DEVICES\NUM_LED;.\DEVICES\SYSTEM;.\DEVICES\TIMER
  group Source Group 1
    ./: STARTUP.A51
  group APP
    ./APP/: main.c
  group DEVICES
    ./DEVICES/NUM_LED/: num_led.c
    ./DEVICES/TIMER/: timer.c
