# Keil uVision project TEST.uvprojx, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: TEST +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\DEVICES\LED;.\DEVICES\TIMER;.\DEVICES\SYSTEM;.\DEVICES\NUM_LED
  group Source Group 1
    ./: STARTUP.A51
  group APP
    ./APP/: main.c
  group DEVICES
    ./DEVICES/LED/: led.c
    ./DEVICES/TIMER/: timer.c
    ./DEVICES/NUM_LED/: num_led.c
