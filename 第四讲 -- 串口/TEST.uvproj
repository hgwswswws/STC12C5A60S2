# Keil uVision project TEST.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: TEST +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\DEVICES\UART;.\DEVICES\TIMER;.\DEVICES\SYSTEM;.\DEVICES\NUM_LED
  group Source Group 1
    ./: STARTUP.A51
  group APP
    ./APP/: test.c
  group DEVICES
    ./DEVICES/NUM_LED/: num_led.c
    ./DEVICES/SYSTEM/: delay.c
    ./DEVICES/TIMER/: timer.c
    ./DEVICES/UART/: uart.c
